# Keil uVision project mindows.uvproj, settings and files
target RTOS_Mindows (ARM-GNU)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: mindows +hex
  group mindows
    ../mindows/: mds_core_a.asm mds_core_c.c mds_chip.c mds_task.c mds_sem.c mds_queue.c
  group srccode
    ../srccode/: mds_userboot.c device.c test.c unoptimize.c interrupt.c
  group others
    ../others/: startup.s ADuC702X.ld
